FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://wlan_ath.cfg"
