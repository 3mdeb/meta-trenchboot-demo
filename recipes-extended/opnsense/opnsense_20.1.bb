require opnsense.inc

SRC_URI[md5sum] = "aed2c9898acb7f49ea37ef1d304cc38f"
SRC_URI[sha256sum] = "27544a78ae03d480a483cfd2e7cfa703b60e50938a1ed188ec3ccde6c426fefe"
