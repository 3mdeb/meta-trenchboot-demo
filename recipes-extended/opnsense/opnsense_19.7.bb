require opnsense.inc

SRC_URI[md5sum] = "0e94eb17fd595d8f54b600e7c9ac45c0"
SRC_URI[sha256sum] = "6fffefa0b09daea397e83f67bf730392125b720043c455597c05d3d80c2baa29"
